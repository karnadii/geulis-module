## boards/arm/geulis/Kconfig.board
```kconfig
# SPDX-License-Identifier: MIT

config BOARD_GEULIS
	bool "Geulis"
	depends on SOC_NRF52840_QIAA
```
